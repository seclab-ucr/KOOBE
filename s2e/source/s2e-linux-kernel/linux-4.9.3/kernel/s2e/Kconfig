## s2e/source/s2e-linux-kernel/linux-4.9.3/kernel/s2e/Kconfig
```kconfig
config S2E
    bool "S2E"
    default y
    help
      Say Y here if you want to enable S2E support.
```
